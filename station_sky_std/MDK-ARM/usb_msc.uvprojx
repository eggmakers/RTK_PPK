# Keil uVision project usb_msc.uvprojx, settings and files
target usb_msc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: usb_msc_remap +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FatFs/src;..\User\main;..\System;..\Middlewares\ST\STM32_USB_Device_Library\User;..\Middlewares\Third_Party\FatFs\drv;..\Middlewares\Third_Party\FatFs\user;..\User\usart;..\User\uavcan\driver;..\User\uavcan\user
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../User/main/: gpio.c main.c boot.c time.c param.c log.c
  group Usart
    ../User/usart/: dma.c gnss.c parse_rtcm.c usart.c usart_dma2ringbuf.c
  group System
    ../System/: stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c startup_stm32f405xx.s
  group FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group Fatfs/usr
    ../Middlewares/Third_Party/FatFs/user/: fatfs.c fatfs_platform.c
  group Fatfs/drv
    ../Middlewares/Third_Party/FatFs/drv/: bsp_driver_sd.c sd_diskio.c sdio.c
  group Uavcan/drv
    ../User/uavcan/driver/: can_bus.c canard.c uavcan.c
  group Uavcan/usr
    ../User/uavcan/user/: gnss_RTCMStream.c mmc_GnssEcef.c uavcan_get_node_info.c uavcan_node_status.c uavcan_reboot.c uavcan_Timestamp.c uavcan_update_firmware.c gnss_Auxiliary.c gnss_ECEFPositionVelocity.c gnss_Fix2.c gnss_Fix.c ahrs_MagneticFieldStrength.c param_Empty.c param_ExecuteOpcode.c param_GetSet.c param_NumericValue.c param_Value.c
  group USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group USB/usr
    ../Middlewares/ST/STM32_USB_Device_Library/User/: usb_device.c usbd_conf.c usbd_desc.c usbd_storage_if.c
  group STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_can.c
software components: CMSIS:CORE 4.3.0
