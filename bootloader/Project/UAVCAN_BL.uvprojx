# Keil uVision project UAVCAN_BL.uvprojx, settings and files
target UAVCAN_BL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UAVCAN_BL +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ..\Core\inc\core;..\Core\inc;..\Lib\canard;..\Lib\STM32F4xx_HAL_Driver\Inc\Legacy;..\Lib\STM32F4xx_HAL_Driver\Inc;..\Source\main;..\Source\drivers;..\Source\uavcan\uavcan;..\Source\uavcan\uavcan\protocol;..\Source\uavcan\;..\Source\indicator;..\Source\read_write;..\Source\boot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ../Source/main/: info.h stm32f4xx_it.c main.c info.c
  group boot
    ../Source/boot/: boot.c
  group indicator
    ../Source/indicator/: light.c
  group uavcan
    ../Source/uavcan/: uavcan.c uavcan_get_node_info.c uavcan_node_status.c uavcan_reboot.c uavcan_allocatee_id.c uavcan_file_read.c param_ExecuteOpcode.c param_GetSet.c param_NumericValue.c param_Value.c param_Empty.c
  group read_write
    ../Source/read_write/: hw_crc.c read_write.c sw_crc.c
  group drivers
    ../Source/drivers/: io.h system.c time.c can_bus.c led.c flash.c watchdog.c param.c log.c
  group core
    ../Core/src/: system_stm32f4xx.c startup_stm32f405xx.s
  group lib_hal
    ../Lib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c
  group lib_canard
    ../Lib/canard/: canard.c
software components: CMSIS:CORE 5.2.0
